# Keil uVision project BC95.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BC95 +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\SHELL;..\BC95;..\HARDWARE\ring_buffer;..\SIM800A;..\GPRS_HANDLE;..\HARDWARE\CRC16;..\HARDWARE\fram_gas;..\HARDWARE\spi;..\ENC28J60;..\HARDWARE\GET_MAC;..\HARDWARE\IWDG
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/ring_buffer/: ring_buffer.c
    ../HARDWARE/fram_gas/: fram_gas.c
    ../HARDWARE/spi/: spi.c
    ../HARDWARE/GET_MAC/: get_mac.c
    ../HARDWARE/CRC16/: crc16.c
    ../HARDWARE/IWDG/: iwdg.c
  group FWLIB
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c misc.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_iwdg.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu.h os_cpu_a.asm
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group SHELL
    ../SHELL/: shell.c
  group BC95
    ../BC95/: bc95.c
  group SIM800A
    ../SIM800A/: sim800a.c
  group GPRS_HANDLE
    ../GPRS_HANDLE/: gprs_handle.c
  group ENC28J60
    ../ENC28J60/: enc28j60.c
